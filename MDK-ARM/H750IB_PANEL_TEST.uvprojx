# Keil uVision project H750IB_PANEL_TEST.uvprojx, settings and files
target H750IB_PANEL_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750IBKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H750IB_PANEL_TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;                           ../Drivers/STM32H7xx_HAL_Driver/Inc;                           ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                           ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                           ../Drivers/CMSIS/Include;           ../Utilities/JPEG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: bsp_qspi_w25q256.c w9825g6jb.c test_jpg.c main.c gpio.c dma2d.c fmc.c jpeg.c ltdc.c mdma.c quadspi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
software components: CMSIS:CORE 4.3.0
